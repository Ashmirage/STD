# Keil uVision project usart_printf.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart_printf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Common;..\usart_printf;..\..\Modules\Usart;..\..\Modules\Stepmotor;..\..\Modules\TFT_LCD;..\..\Modules\Relay;..\..\Modules\AD;..\..\Modules\TPR;..\..\Modules\Time;..\..\Modules\Scheduler;..\..\Modules\Matrix_keyboard;..\..\Modules\LED;..\..\Modules\Buzzer;..\..\Modules\TIM;..\..\Modules\LDR;..\..\Modules\DHT11;..\..\Modules\PWM;..\..\Modules\Motor;..\..\Modules\SPI;..\..\Modules\W25Q128;..\..\Modules\RTC_CLK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../Common/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
    ./USER/: main.c
  group Hardware
    ../../Modules/Usart/: my_usart.c my_usart.h
    ../../Modules/Stepmotor/: stepmotor.c stepmotor.h
    ../../Modules/TFT_LCD/: Lcd.c Lcd.h UI.c UI.h chinese_font.c chinese_font.h
    ../../Modules/Relay/: Relay.c Relay.h
    ../../Modules/AD/: AD.c AD.h
    ../../Modules/TPR/: Temp.c Temp.h
    ../../Modules/Scheduler/: scheduler.c Scheduler.h
    ../../Modules/Matrix_keyboard/: Matrix_keyboard.c Matrix_keyboard.h
    ../../Modules/LED/: LED.c LED.h
    ../../Modules/Buzzer/: Buzzer.c Buzzer.h
    ../../Modules/TIM/: TIM_IT.c TIM_IT.h
    ../../Modules/LDR/: LDR.c LDR.h
    ../../Modules/DHT11/: DHT11.c DHT11.h
    ../../Modules/PWM/: PWM.c PWM.h
    ../../Modules/Motor/: Motor.c Motor.h
    ../../Modules/SPI/: SPI.c SPI.h
    ../../Modules/W25Q128/: W25Q128.c W25Q128.h W25Q128_Ins.h
    ../../Modules/RTC_CLK/: RTC_clk.c RTC_clk.h
    ../../Modules/Time/: my_time.c my_time.h
