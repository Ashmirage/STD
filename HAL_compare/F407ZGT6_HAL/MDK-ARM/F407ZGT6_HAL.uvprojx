# Keil uVision project F407ZGT6_HAL.uvprojx, settings and files
target F407ZGT6_HAL (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407ZGT6_HAL +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../SYS;../../BSP/LED;../../BSP/Matrix_keyboard;../../BSP/Usart;../../BSP/Relay;../../BSP/Buzzer;../../BSP/DHT11;../../SYS/scheduler;../../SYS/delay_us;../../BSP/LCD;../../BSP/sys;../../BSP/UI;../../BSP/REMOTE;../../BSP/Countsensor;../../BSP/SYN6288;../../BSP/HW;../../BSP/24CXX;../../BSP/IIC;../../BSP/Pot;../../BSP/AD;../../BSP/Motor;../../BSP/LDR;../../BSP/TPR;../../BSP/Stepmotor;../../BSP/RTC_CLK
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fsmc.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../../BSP/LED/: led.c led.h
    ../../BSP/Matrix_keyboard/: Matrix_keyboard.c Matrix_keyboard.h
    ../../BSP/Usart/: my_usart.c my_usart.h
    ../../BSP/Relay/: Relay.c Relay.h
    ../../BSP/Buzzer/: Buzzer.c Buzzer.h
    ../../BSP/LCD/: FONT.H lcd.c lcd.h lcd_font.h
    ../../BSP/UI/: UI.c UI.h
    ../../BSP/REMOTE/: remote.c remote.h
    ../../BSP/MY_TIM/: TIM_All_callback.c
    ../../BSP/Countsensor/: CountSensor.c CountSensor.h
    ../../BSP/MY_EXTI/: EXTI_All_callback.c
    ../../BSP/HW/: HW.c HW.h
    ../../BSP/24CXX/: 24cxx.c 24cxx.h
    ../../BSP/IIC/: myiic.c myiic.h
    ../../BSP/Pot/: pot.c pot.h
    ../../BSP/AD/: AD.c AD.h
    ../../BSP/Motor/: Motor.c Motor.h
    ../../BSP/DHT11/: DHT11.c DHT11.h
    ../../BSP/LDR/: LDR.c LDR.h
    ../../BSP/TPR/: Temp.c Temp.h
    ../../BSP/Stepmotor/: stepmotor.c stepmotor.h
    ../../BSP/RTC_CLK/: RTC_clk.c RTC_clk.h
    ../../BSP/SYN6288/: syn6288.c syn6288.h
  group SYS
    ../../SYS/scheduler/: scheduler.c Scheduler.h
    ../../SYS/delay_us/: delay_us.c delay_us.h
    ../../BSP/sys/: sys.c sys.h
software components: CMSIS:CORE 5.5.0
